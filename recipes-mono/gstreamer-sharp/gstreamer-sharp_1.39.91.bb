require gstreamer-sharp.inc

inherit pkgconfig

SRCREV = "bf18e534a96079ce46b34a2e2afd7d8d23aef915"
